# Keil uVision project DCmotorSpeedControlSystem.uvproj, settings and files
target STC89C52 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: STC89C52 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\code;.\code\header;.\code\source
  group main
    ./: STARTUP.A51
    ./code/: main.c
  group source
    ./code/source/: Delay.c Led.c Timer.c Motor.c Pid.c
target 8051_all (MCS-51)
  device: 8051 (all Variants) Generic
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: 8051_all +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\code;.\code\header;.\code\source
